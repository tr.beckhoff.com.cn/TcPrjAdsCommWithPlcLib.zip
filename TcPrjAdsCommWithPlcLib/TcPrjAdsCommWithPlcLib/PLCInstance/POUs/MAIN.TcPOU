PROGRAM MAIN
VAR

END_VAR




PRG_Calc();

END_PROGRAM
