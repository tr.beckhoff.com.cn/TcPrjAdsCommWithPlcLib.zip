PROGRAM PRG_Calc
VAR
	iPrgVar			:INT;
END_VAR


iPrgVar := iPrgVar + 2;

iGlobalVar := iGlobalVar + 1;

END_PROGRAM
