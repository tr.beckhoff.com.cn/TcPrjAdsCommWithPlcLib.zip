//{attribute 'qualified_only'}
VAR_GLOBAL
	 {attribute 'tc_no_symbol'}
	iGlobalVar			:INT;
END_VAR
